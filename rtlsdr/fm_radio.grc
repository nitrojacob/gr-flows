options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: oversampling
  id: variable
  parameters:
    value: '4'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.14'
  states: {}
- name: pll_max_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: display_tab@1
    label: PLL MAX FREQ
    start: '0'
    step: '0.001'
    stop: pi
    value: pi/2
  states: {}
- name: pll_min_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: display_tab@1
    label: PLL MIN FREQ
    start: '-pi'
    step: '0.001'
    stop: '0'
    value: '-pi/2'
  states: {}
- name: rf_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: display_tab@0
    label: RF FREQ
    start: '50000000'
    step: '1000000'
    stop: '1700000000'
    value: '92700000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: pll_max_freq
    min_freq: pll_min_freq
    w: '.00314'
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/oversampling
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {state: disabled}
- name: display_tab
  id: qtgui_tab_widget
  parameters:
    label0: RF
    label1: Baseband
    label2: Others
    num_tabs: '3'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/oversampling/2
    decim: oversampling
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/oversampling/20
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'IQ FM Demodulation: https://www.allaboutcircuits.com/textbook/radio-frequency-analysis-design/radio-frequency-demodulation/quadrature-frequency-and-phase-demodulation/'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/oversampling
    fc: '0'
    fftsize: '1024'
    gui_hint: display_tab@1
    name: QT GUI Plot
    type: float
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: rf_freq
    fftsize: '1024'
    gui_hint: display_tab@0
    name: QT GUI Plot
    plotconst: 'False'
    plotfreq: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/oversampling/32000)
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: rf_freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pll_freqdet_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pll_freqdet_cf_0, '0', qtgui_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_pll_freqdet_cf_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
