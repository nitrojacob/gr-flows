options:
  parameters:
    generate_options: qt_gui
    id: visualizer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: centre_frequency_MHz
  id: variable_qtgui_range
  parameters:
    label: Centre Frequency (MHz)
    start: '1'
    step: '1'
    stop: '100'
    value: '27.0'
  states: {}
- name: decimation_a
  id: variable
  parameters:
    value: '2'
  states: {}
- name: decimation_b
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1'
    max_gain: '100'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate/decimation_a
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '1000'
    audio_stop: '2000'
    chan_rate: samp_rate/decimation_a
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/jacob/Desktop/fire_truck.bin
    type: byte
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '256'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.100'
    init: '0'
    low: '-0.100'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '256'
    type: float
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      For the 27MHz remote we found the modulation to be ASK by oberving the RF time domain waveform
      AM demodulation followed by symbol synchrnization and thresholding gives us a binary steam of
      1s and 0s. We find through the AM modulator output waveform that the messages have a fixed
      frame start of 110110110 followed by alternating 1s and 0s of variable length (length depends
      on key pressed). This block analyses the total frame length.



      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, tag = "1,1,1,0,1,1,1,0,1,1,1,0", threshold=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Custom Decode Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              tag_ = tag.split(",")
              self.tag = np.array([int(x)*2.0-1.0 for x in tag_])
              #self.tag = tag*2 - 1  #[0, 1] range to [-1, 1] range
              #print(self.tag)
              self.threshold = threshold

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #output_items[0][:] = input_items[0] * self.example_param
              bitstream = input_items[0] *2 -1   #[0, 1] range to [-1, 1] range
              correlation = np.correlate(bitstream, self.tag, "same")
              detection_idx = np.argwhere(correlation >= len(self.tag)-self.threshold-1).reshape([-1,]) #Indices where a correlation is found
              lengths = detection_idx[1:]-detection_idx[:-1]  #find distance betwee each adjacent correlations
              output_items[0][:] = np.zeros_like(input_items[0]) #default value of output is 0
              for i in range(len(detection_idx)-1):
                  idx = detection_idx[i]
                  length = lengths[i]
                  output_items[0][idx] = length  #At the places where we found the correlation, replace the value with the frame length (frame length includes length of frame marker)
              print(np.max(output_items[0]))
              output_items[0][-1] = len(output_items[0])  #Keep last entry as block length to catch situations where the block length is less than the frame length
              #print(lengths)
              return len(output_items[0])
    tag: '''1,1,1,0,1,1,1,0,1,1,1,0'''
    threshold: '1'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decimation_a
    taps: '[1,0.5,0.1,0,0,0,0.1,0.5]'
    type: ccc
  states: {}
- name: gui_tab
  id: qtgui_tab_widget
  parameters:
    label0: RF
    label1: BB
    label2: Binary
    num_tabs: '3'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '14000'
    decim: decimation_b
    gain: '1'
    samp_rate: samp_rate/decimation_a
    type: fir_filter_fff
    width: '1400'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimation_a
    fc: '0'
    fftsize: '1024'
    gui_hint: gui_tab@1
    plotconst: 'False'
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: gui_tab@0
    plotconst: 'False'
    plotfreq: 'False'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: gui_tab@2
    size: '1024'
    srate: bit_rate
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: centre_frequency_MHz * 1e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_agc2_xx_0, '0', analog_fm_demod_cf_0, '0']
- [analog_am_demod_cf_0, '0', low_pass_filter_0, '0']
- [analog_am_demod_cf_0, '0', qtgui_sink_x_0, '0']
- [analog_fm_demod_cf_0, '0', low_pass_filter_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_sink_x_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_threshold_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', epy_block_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_threshold_ff_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [fir_filter_xxx_0, '0', analog_agc2_xx_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [rtlsdr_source_0, '0', fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
